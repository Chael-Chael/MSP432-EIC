# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Lib\driverlib\MSP432P4xx;..\Lib\inc;..\Lib\inc\CMSIS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ./: main.c
  group Lib
    ../Lib/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
    ../Lib/inc/: Clock.h UART0.h Clock.c UART0.c
  group Startup
    ./RTE/Device/MSP432P401R/: system_msp432p401r.c startup_msp432p401r_uvision.s
